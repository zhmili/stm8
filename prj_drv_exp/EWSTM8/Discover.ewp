# IAR project Discover.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\proj\prj_stm8\STM8S_StdPeriph_Driver\inc; E:\proj\prj_stm8\STM8S_StdPeriph_Driver\src; E:\proj\prj_stm8\prj_drv_exp\Modbus; E:\proj\prj_stm8\prj_drv_exp\inc; E:\proj\prj_stm8\prj_drv_exp\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Discover.srec
  ILINK.IlinkOutputFile: Discover.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../inc/: bsp.h includes.h stm8_tsl_conf.h stm8s_conf.h
  group Modbus
    ../Modbus/: modbus.c modbus.h
  group Source Files
    ../src/: brush_mot.c brush_mot.h bsp.c delay.c I2c_slave_interrupt.c I2c_slave_interrupt.h main.c servo.c servo.h stm8s_it.c test.c ult.c
  group STM8S_StdPeriph_Lib/inc
    ../../STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_can.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_tim5.h stm8s_tim6.h stm8s_uart1.h stm8s_uart2.h stm8s_uart3.h stm8s_uart4.h stm8s_wwdg.h
  group STM8S_StdPeriph_Lib/src
    ../../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
